# Keil uVision project QRcode.uvprojx, settings and files
target QRcode (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Camera +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER,STM32H743xx
  c misc: --diag_suppress=1,111,177,550,187,188,186,1293,68
  c include: ..\..\zonesion\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\zonesion\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\zonesion\Libraries\CMSIS\Include;..\..\zonesion\Libraries;..\..\zonesion\Source\common\sys;..\..\zonesion\Source\common\lcd;..\..\zonesion\Source\common;..\..\zonesion\Source\dev;..\..\zonesion\Source;..\..\zonesion\Source\qrcoder\ZBar;..\..\zonesion\Source\qrcoder\ZBar\decoder;..\..\zonesion\Source\qrcoder\ZBar\processor;..\..\zonesion\Source\qrcoder\ZBar\qrcode;..\..\zonesion\Source\malloc;..\..\zonesion\Source\convert
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\QRcode.sct
  group CMSIS
    ../../zonesion/Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group FWLIB
    ../../zonesion/Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sram.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_dcmi.c
  group STARTUP
    ../../zonesion/Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group Source
    ./: QRcode.sct
    ../../zonesion/Source/: stm32h7xx_hal_conf.h readme.txt main.c stm32h7xx_it.c qr_decoder_app.c
    ../../zonesion/Source/common/sys/: delay.c key.c led.c spi.c usart.c w25qxx.c
    ../../zonesion/Source/common/lcd/: ili9806.c text.c
    ../../zonesion/Source/common/: lcd.c sysconfig.c
    ../../zonesion/Source/dev/: dcmi.c ov2640.c sccb.c timer.c gui.c
    ../../zonesion/Source/malloc/: malloc.c
  group ZBar
    ../../zonesion/Source/qrcoder/ZBar/: config.c convert.c decoder.c error.c image.c img_scanner.c refcnt.c scanner.c symbol.c
    ../../zonesion/Source/qrcoder/ZBar/decoder/: code128.c ean.c qr_finder.c
    ../../zonesion/Source/qrcoder/ZBar/qrcode/: bch15_5.c binarize.c isaac.c qrdec.c qrdectxt.c rs.c util.c
  group convert
    ../../zonesion/Source/convert/: cc936.c unicodetogb2312.c utf8togbk.c
