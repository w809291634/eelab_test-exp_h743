# Keil uVision project GasRange.uvprojx, settings and files
target GasRange (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: GasRange +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER,STM32H743xx
  c misc: --diag_suppress=1,177,550
  c include: ..\..\zonesion\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\zonesion\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\zonesion\Libraries\CMSIS\Include;..\..\zonesion\Libraries;..\..\zonesion\Source\common\sys;..\..\zonesion\Source\common\lcd;..\..\zonesion\Source\common;..\..\zonesion\Source\dev;..\..\zonesion\Source;..\..\zonesion\Source\gui;..\..\zonesion\Source\picture
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group CMSIS
    ../../zonesion/Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group FWLIB
    ../../zonesion/Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sram.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c
  group STARTUP
    ../../zonesion/Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group Source
    ../../zonesion/Source/: main.c stm32h7xx_it.c readme.txt stm32h7xx_hal_conf.h
    ../../zonesion/Source/common/sys/: delay.c key.c led.c spi.c usart.c w25qxx.c rgb.c
    ../../zonesion/Source/common/lcd/: ili9806.c text.c
    ../../zonesion/Source/common/: lcd.c sysconfig.c
  group dev
    ../../zonesion/Source/dev/: buzzer.c Flame.c MP-4.c Relay.c timer.c
  group Picture
    ../../zonesion/Source/picture/: aux_logo.c flame_big_off.c flame_big_on.c flame_high_off.c flame_high_on.c flame_medium_off.c flame_medium_on.c flame_off.c flame_on_1.c flame_on_2.c flame_on_3.c flame_on_4.c flame_small_off.c flame_small_on.c gas_leakage_f.c gas_leakage_t.c identification.c total_switch_off.c total_switch_on.c
